# Keil uVision project USART.uvprojx, settings and files
target USART (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USART +hex
  c flags: Optim=1 uC99=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\FUNCTION;..\STM32_USB-FS-Device_Driver\inc;..\USB\inc;..\HARDWARE\IIC;..\HARDWARE\MPU9250;..\iNEMO_AHRS_v121\inc;..\HARDWARE\TIMER;..\HARDWARE\ENCODER;..\STM32_Cryptographic_Library\binary\MK-ARM;..\STM32_Cryptographic_Library\inc;..\STM32_Cryptographic_Library\inc\AES;..\STM32_Cryptographic_Library\inc\AES\CBC;..\STM32_Cryptographic_Library\inc\AES\CTR;..\STM32_Cryptographic_Library\inc\AES\Common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c BSP_init.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/MPU9250/: IIC_MPU9250.c
    ../HARDWARE/TIMER/: timer_function.c
    ../HARDWARE/ENCODER/: encoder.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group README
    ../: README.TXT
  group FUNCTION
    ../FUNCTION/: us_can_zyt.c us_mcu_transfer.c usbio.c pwm.c timer_interrupt.c PID.C contact.c odometry.c imu_uranus.c libMCUAuthenticate.c us_aes_func.c
    ../STM32_Cryptographic_Library/binary/MK-ARM/: M3_CryptoFW_2_0_6.lib M3_CryptoFW_L1xx_2_0_6.lib M3_CryptoFW_RngHW_2_0_6.lib M3_CryptoHW_2_0_6.lib
  group STM32_USB-FS-Device_Driver
    ../STM32_USB-FS-Device_Driver/src/: otgd_fs_cal.c otgd_fs_dev.c otgd_fs_int.c otgd_fs_pcd.c usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group USB
    ../USB/: usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group AHRS
    ../iNEMO_AHRS_v121/src/: iNEMO_AHRS.c iNEMO_AHRS_MemMan_1.c iNEMO_EKF.c iNEMO_math.c
